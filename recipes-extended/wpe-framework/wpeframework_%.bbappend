inherit syslog-ng-config-gen

SYSLOG-NG_FILTER = "wpeframework"
SYSLOG-NG_SERVICE_wpeframework = "wpeframework.service"
SYSLOG-NG_DESTINATION_wpeframework = "wpeframework.log"
SYSLOG-NG_LOGRATE_wpeframework = "high"
